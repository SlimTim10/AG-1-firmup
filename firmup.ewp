# IAR project firmup.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5310 MSP430F5310
  General.GStackSize2: 300
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430f5310_firmup.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: CC430F5133 CC430F5133
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F5133.xcl
  group (top)
    ./: circuit.c circuit.h flash.c flash.h lnk430f5310_firmup.xcl main.c msp430f5310_extra.c msp430f5310_extra.h sdfat.c sdfat.h spi.c spi.h util.c util.h
